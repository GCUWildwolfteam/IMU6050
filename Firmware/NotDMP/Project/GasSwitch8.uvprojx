# Keil uVision project GasSwitch8.uvprojx, settings and files
target STM32F103T8U6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GasSwitch8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Drivers;..\Devices;..\Apps;..\Tasks;..\Libraries\FreeRTOS\include;..\Libraries\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c typedefs.h user_common.h FreeRTOSConfig.h
  group Tasks
    ../Tasks/: sensors.c
  group Apps
    ../Apps/: Filter.c
  group Devices\MPU6050_DMP
    ../Devices/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group Devices
    ../Devices/: M3508_Motor.c mpu6050.c LED.c
  group Drivers
    ../Drivers/: delay.c GPIO.c NVIC.c USART.c TIM.c CAN.c Flash.c I2C_SW.c
  group FreeRTOS\Source
    ../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS\Portable
    ../Libraries/FreeRTOS/portable/MemMang/: heap_4.c
    ../Libraries/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Libraries\StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
